## boards/shields/tickler41/Kconfig.defconfig
```kconfig
if SHIELD_TICKLER41

config ZMK_KEYBOARD_NAME
    default "ticklerfour1"

endif # SHIELD_TICKLER41
```
